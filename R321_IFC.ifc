Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: Project Number
Time: 2021-11-01T17:09:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 01 17:09:17 2021 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{8E989234-0FD2-4467-8DE7-86D07328F33F}\ifc * Database version: 5507 * Database creation date: Mon Nov 01 17:09:14 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 01 17:09:14 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 01 17:09:14 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowController: Battery Operated Tap with Temperature Adjustment Lever Brushed Stainless Steel, 1
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_Chrome, Duten_Metal_BrushedStainlessSteel, Duten_Plastic_Black
Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Tap with Temperature Adjustment Lever Brushed Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Battery Operated Tap with Temperature Adjustment Lever Chrome, 2
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_Chrome, Duten_Plastic_Black
Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Tap with Temperature Adjustment Lever Chrome; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Battery Operated Tap with Temperature Adjustment Lever Matte Black, 3
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_Chrome, Duten_Metal_MatteBlack, Duten_Plastic_Black
Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Tap with Temperature Adjustment Lever Matte Black; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Mains Operated Tap with Temperature Adjustment Lever Brushed Stainless Steel, 4
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_Chrome, Duten_Metal_BrushedStainlessSteel, Duten_Plastic_Black
Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Tap with Temperature Adjustment Lever Brushed Stainless Steel; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Mains Operated Tap with Temperature Adjustment Lever Chrome, 5
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_Chrome, Duten_Plastic_Black
Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Tap with Temperature Adjustment Lever Chrome; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Mains Operated Tap with Temperature Adjustment Lever Matte Black, 6
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_Chrome, Duten_Metal_MatteBlack, Duten_Plastic_Black
Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Tap with Temperature Adjustment Lever Matte Black; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a
